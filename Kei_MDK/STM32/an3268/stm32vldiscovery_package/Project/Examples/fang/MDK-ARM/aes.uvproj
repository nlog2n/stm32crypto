# Keil uVision project aes.uvproj, settings and files
target Flash Program (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sies (library)
  c flags: Optim=4 oTime=1 wLevel=2
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../: readme.txt
  group User
    ../aes/: aes_core.c
    ../hash/: hash.c
    ../: config.c
    ../pack/: unpack.c keyupdate.c pack.c sendcnt.c
